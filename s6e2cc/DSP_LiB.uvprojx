# Keil uVision project DSP_LiB.uvprojx, settings and files
target s6e2cc_template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S6E2CCAJ0A Cypress
  pack: Keil.FM4_DFP.1.4.0
  cpu: IRAM(0x1FFD0000,0x30000) IRAM2(0x20038000,0x10000) IROM(0x00000000,0x200000) IROM2(0x00406000,0xA000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DSP_LiB
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\drivers;.\RTE\Device\S6E2CCAJ0A;.\src;.\src\dac_estimation;.\drivers
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
  group src
    ./src/: ANC_NLMS_v1.c
  group drivers
    ./drivers/: audio.c delay.c gpio.c i2c.c i2s.c dstc.c uart_io.c dt.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Device:Startup 1.0.0
